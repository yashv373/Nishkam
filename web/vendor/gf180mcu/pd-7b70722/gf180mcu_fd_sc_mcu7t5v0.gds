* Circuit, read from the shapes
.subckt gf180mcu_fd_sc_mcu7t5v0__sdffq_1 CLK D Q SE SI VDD VNW VSS
XM1 VSS SE n1 VSUBS nfet_05v0 w=0.36u l=0.6u
XM2 n2 SI VSS VSUBS nfet_05v0 w=0.36u l=0.6u
XM3 n3 SE n2 VSUBS nfet_05v0 w=0.36u l=0.6u
XM4 n4 n1 n3 VSUBS nfet_05v0 w=0.36u l=0.6u
XM5 VSS D n4 VSUBS nfet_05v0 w=0.36u l=0.6u
XM6 n5 CLK VSS VSUBS nfet_05v0 w=0.465u l=0.6u
XM7 n6 n5 VSS VSUBS nfet_05v0 w=0.465u l=0.6u
XM8 n7 n5 n3 VSUBS nfet_05v0 w=0.36u l=0.6u
XM9 n8 n6 n7 VSUBS nfet_05v0 w=0.36u l=0.6u
XM10 VSS n9 n8 VSUBS nfet_05v0 w=0.36u l=0.6u
XM11 n9 n7 VSS VSUBS nfet_05v0 w=0.36u l=0.6u
XM12 n10 n6 n9 VSUBS nfet_05v0 w=0.36u l=0.6u
XM13 n11 n5 n10 VSUBS nfet_05v0 w=0.36u l=0.6u
XM14 VSS n12 n11 VSUBS nfet_05v0 w=0.36u l=0.6u
XM15 n12 n10 VSS VSUBS nfet_05v0 w=0.435u l=0.6u
XM16 Q n12 VSS VSUBS nfet_05v0 w=0.815u l=0.6u
XM17 VDD SE n1 VNW pfet_05v0 w=0.63u l=0.5u
XM18 n13 SI VDD VNW pfet_05v0 w=0.63u l=0.5u
XM19 n14 n1 n13 VNW pfet_05v0 w=0.63u l=0.5u
XM20 n15 SE n14 VNW pfet_05v0 w=0.63u l=0.5u
XM21 VDD D n15 VNW pfet_05v0 w=0.63u l=0.5u
XM22 n5 CLK VDD VNW pfet_05v0 w=0.92u l=0.5u
XM23 n6 n5 VDD VNW pfet_05v0 w=0.815u l=0.5u
XM24 n7 n6 n14 VNW pfet_05v0 w=0.63u l=0.5u
XM25 n16 n5 n7 VNW pfet_05v0 w=0.63u l=0.5u
XM26 VDD n9 n16 VNW pfet_05v0 w=0.63u l=0.5u
XM27 n9 n7 VDD VNW pfet_05v0 w=0.63u l=0.51u
XM28 n10 n5 n9 VNW pfet_05v0 w=0.63u l=0.5u
XM29 n17 n6 n10 VNW pfet_05v0 w=0.63u l=0.5u
XM30 VDD n12 n17 VNW pfet_05v0 w=0.63u l=0.5u
XM31 n12 n10 VDD VNW pfet_05v0 w=0.705u l=0.5u
XM32 Q n12 VDD VNW pfet_05v0 w=1.215u l=0.5u
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def P(c, l, *ps):  # polygons
    for p in ps: c.add(gdstk.Polygon(p, *l))
boundary = (0, 0)
nwell = (21, 0)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
dualgate = (55, 0)
v5_xtor = (112, 1)
lvpwell = (204, 0)

gf180mcu_fd_sc_mcu7t5v0_ = lib.new_cell('gf180mcu_fd_sc_mcu7t5v0__sdffq_1')
R(gf180mcu_fd_sc_mcu7t5v0_, boundary, [(0,0,21.28,3.92)])
P(gf180mcu_fd_sc_mcu7t5v0_, nwell, [(-0.43,1.76),(-0.43,4.35),(21.71,4.35),(21.71,1.76),(10,1.76),(10,1.885),(6.245,1.885),(6.245,1.76)])
R(gf180mcu_fd_sc_mcu7t5v0_, comp, [(19.62,0.345,21.1,1.16), (19.62,2.36,21.1,3.575)])
P(gf180mcu_fd_sc_mcu7t5v0_, comp, [(0.18,2.51),(0.18,3.14),(5.24,3.14),(5.24,3.505),(5.6,3.505),(5.6,3.43),(6.88,3.43),(6.88,2.51)],
  [(5.44,0.675),(5.44,0.78),(0.18,0.78),(0.18,1.14),(6.74,1.14),(6.74,1.285),(7.12,1.285),(7.12,0.675)],
  [(7.56,2.485),(7.56,3.645),(7.93,3.645),(7.93,3.3),(9.195,3.3),(9.195,2.485)],
  [(7.715,0.695),(7.715,1.16),(9.055,1.16),(9.055,1.285),(9.415,1.285),(9.415,0.695)],
  [(17.36,2.435),(17.36,2.51),(9.72,2.51),(9.72,3.14),(12.92,3.14),(12.92,3.29),(13.28,3.29),(13.28,3.14),(18.76,3.14),(18.76,2.435)],
  [(17.56,0.3),(17.56,0.79),(9.775,0.79),(9.775,1.15),(19.26,1.15),(19.26,0.715),(17.92,0.715),(17.92,0.3)])
R(gf180mcu_fd_sc_mcu7t5v0_, poly2, [(15.82,2.05,16.32,3.36)])
P(gf180mcu_fd_sc_mcu7t5v0_, poly2, [(1.74,0.56),(1.74,3.36),(2.24,3.36),(2.24,1.36),(2.34,1.36),(2.34,0.56)],
  [(0.62,0.12),(0.62,3.8),(4,3.8),(4,2.29),(3.5,2.29),(3.5,3.6),(1.12,3.6),(1.12,1.36),(1.22,1.36),(1.22,0.32),(2.58,0.32),(2.58,1.36),(3.18,1.36),(3.18,0.12)],
  [(3.7,0.56),(3.7,1.625),(2.48,1.625),(2.48,3.36),(2.98,3.36),(2.98,1.855),(4.3,1.855),(4.3,0.56)],
  [(4.54,0.56),(4.54,2.29),(4.44,2.29),(4.44,3.46),(4.94,3.46),(4.94,1.36),(5.14,1.36),(5.14,0.56)],
  [(5.84,0.455),(5.84,2.21),(5.94,2.21),(5.94,3.65),(6.44,3.65),(6.44,0.455)],
  [(11.335,0.57),(11.335,1.715),(10.16,1.715),(10.16,3.36),(10.66,3.36),(10.66,1.945),(11.76,1.945),(11.76,1.46),(11.935,1.46),(11.935,0.57)],
  [(12.175,0.57),(12.175,1.93),(12.12,1.93),(12.12,3.36),(12.62,3.36),(12.62,2.21),(12.775,2.21),(12.775,0.57)],
  [(13.58,0.57),(13.58,3.36),(14.09,3.36),(14.09,1.38),(14.18,1.38),(14.18,0.57)],
  [(14.7,0.535),(14.7,1.61),(15.08,1.61),(15.08,1.37),(15.3,1.37),(15.3,0.535)],
  [(8.155,0.12),(8.155,2.135),(8.255,2.135),(8.255,3.8),(15.25,3.8),(15.25,2.21),(15.545,2.21),(15.545,1.81),(16.12,1.81),(16.12,1.37),(16.42,1.37),(16.42,0.57),(15.82,0.57),(15.82,1.61),(15.34,1.61),(15.34,2.01),(14.75,2.01),(14.75,3.6),(11.73,3.6),(11.73,2.29),(11.23,2.29),(11.23,3.6),(8.755,3.6),(8.755,0.35),(10.215,0.35),(10.215,1.37),(10.815,1.37),(10.815,0.12)],
  [(16.66,0.57),(16.66,2.29),(16.56,2.29),(16.56,3.36),(17.06,3.36),(17.06,1.685),(17.26,1.685),(17.26,0.57)],
  [(18.22,0.495),(18.22,1.625),(17.82,1.625),(17.82,3.36),(18.32,3.36),(18.32,1.825),(18.52,1.825),(18.52,1.37),(18.82,1.37),(18.82,0.495)],
  [(20.06,0.125),(20.06,1.945),(20.16,1.945),(20.16,3.795),(20.66,3.795),(20.66,0.125)])
P(gf180mcu_fd_sc_mcu7t5v0_, pplus, [(-0.2,1.76),(-0.2,4.12),(21.48,4.12),(21.48,1.76),(10,1.76),(10,1.885),(6.245,1.885),(6.245,1.76)])
P(gf180mcu_fd_sc_mcu7t5v0_, nplus, [(-0.2,-0.2),(-0.2,1.76),(6.245,1.76),(6.245,1.885),(10,1.885),(10,1.76),(21.48,1.76),(21.48,-0.2)])
R(gf180mcu_fd_sc_mcu7t5v0_, contact, [(17.63,0.37,17.85,0.59), (19.69,0.675,19.91,0.895), (20.81,0.675,21.03,0.895), (7.785,0.765,8.005,0.985), (18.97,0.82,19.19,1.04), (0.25,0.85,0.47,1.07), (1.37,0.85,1.59,1.07), (3.33,0.85,3.55,1.07), (5.355,0.85,5.575,1.07), (9.845,0.86,10.065,1.08), (10.965,0.86,11.185,1.08), (13.04,0.86,13.26,1.08), (14.33,0.86,14.55,1.08), (15.45,0.86,15.67,1.08), (6.81,0.995,7.03,1.215), (9.125,0.995,9.345,1.215), (14.79,1.32,15.01,1.54), (16.97,1.32,17.19,1.54), (13.685,1.475,13.905,1.695), (0.75,1.53,0.97,1.75), (1.88,1.53,2.1,1.75), (17.89,1.72,18.11,1.94), (20.26,1.785,20.48,2.005), (2.55,1.79,2.77,2.01), (6.05,1.895,6.27,2.115), (8.375,1.935,8.595,2.155), (4.635,1.945,4.855,2.165), (10.33,2.03,10.55,2.25), (12.28,2.075,12.5,2.295), (15.965,2.12,16.185,2.34), (19.74,2.56,19.96,2.78), (20.81,2.56,21.03,2.78), (6.59,2.58,6.81,2.8), (8.905,2.58,9.125,2.8), (10.86,2.59,11.08,2.81), (14.33,2.59,14.55,2.81), (15.45,2.59,15.67,2.81), (18.47,2.67,18.69,2.89), (3.13,2.71,3.35,2.93), (0.25,2.725,0.47,2.945), (9.79,2.75,10.01,2.97), (1.32,2.85,1.54,3.07), (17.31,2.85,17.53,3.07), (12.99,3,13.21,3.22), (19.74,3.085,19.96,3.305), (20.81,3.085,21.03,3.305), (5.31,3.185,5.53,3.405), (7.63,3.355,7.85,3.575)])
R(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(0.705,0.595,1.03,2.15), (1.825,0.595,2.15,2.15), (20.79,0.615,21.15,3.365), (3.41,1.795,5.085,2.215), (5.465,1.795,6.63,2.2)])
P(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(0.245,0.79),(0.245,3.015),(0.475,3.015),(0.475,2.615),(2.775,2.615),(2.775,1.625),(2.545,1.625),(2.545,2.385),(0.475,2.385),(0.475,0.79)],
  [(6.75,0.99),(6.75,1.275),(6.86,1.275),(6.86,2.43),(6.585,2.43),(6.585,2.86),(6.815,2.86),(6.815,2.66),(8.6,2.66),(8.6,1.875),(8.37,1.875),(8.37,2.43),(7.09,2.43),(7.09,0.99)],
  [(9.785,2.69),(9.785,3.12),(8.6,3.12),(8.6,2.89),(7.09,2.89),(7.09,3.09),(6.105,3.09),(6.105,2.705),(3.03,2.705),(3.03,2.935),(5.875,2.935),(5.875,3.32),(7.32,3.32),(7.32,3.12),(8.37,3.12),(8.37,3.35),(10.015,3.35),(10.015,2.69)],
  [(6.09,0.53),(6.09,1.305),(4.655,1.305),(4.655,0.845),(3.27,0.845),(3.27,1.075),(4.425,1.075),(4.425,1.535),(6.32,1.535),(6.32,0.76),(7.32,0.76),(7.32,1.535),(8.605,1.535),(8.605,0.76),(9.84,0.76),(9.84,1.14),(10.07,1.14),(10.07,0.53),(8.375,0.53),(8.375,1.305),(7.55,1.305),(7.55,0.53)],
  [(10.96,0.8),(10.96,1.47),(10.855,1.47),(10.855,2.87),(11.085,2.87),(11.085,1.7),(13.965,1.7),(13.965,1.47),(11.19,1.47),(11.19,0.8)],
  [(14.325,0.8),(14.325,2.07),(12.2,2.07),(12.2,2.3),(14.325,2.3),(14.325,2.87),(14.555,2.87),(14.555,0.8)],
  [(9.065,0.99),(9.065,1.82),(8.9,1.82),(8.9,2.86),(9.13,2.86),(9.13,2.05),(10.325,2.05),(10.325,3.39),(12.49,3.39),(12.49,2.765),(13.67,2.765),(13.67,3.39),(16.245,3.39),(16.245,2.07),(15.905,2.07),(15.905,3.16),(15.015,3.16),(15.015,1.26),(14.785,1.26),(14.785,3.16),(13.9,3.16),(13.9,2.53),(12.26,2.53),(12.26,3.15),(10.555,3.15),(10.555,1.82),(9.295,1.82),(9.295,1.275),(9.405,1.275),(9.405,0.99)],
  [(15.445,0.8),(15.445,2.87),(15.675,2.87),(15.675,1.775),(16.505,1.775),(16.505,2.55),(18.17,2.55),(18.17,1.67),(17.83,1.67),(17.83,2.315),(16.735,2.315),(16.735,1.54),(15.675,1.54),(15.675,0.8)],
  [(18.965,0.76),(18.965,0.995),(16.965,0.995),(16.965,1.6),(17.195,1.6),(17.195,1.23),(18.965,1.23),(18.965,1.78),(18.465,1.78),(18.465,2.95),(18.695,2.95),(18.695,2.01),(20.54,2.01),(20.54,1.78),(19.195,1.78),(19.195,0.76)],
  [(0,-0.3),(0,0.3),(1.365,0.3),(1.365,1.14),(1.595,1.14),(1.595,0.3),(5.295,0.3),(5.295,1.075),(5.635,1.075),(5.635,0.3),(7.78,0.3),(7.78,1.045),(8.01,1.045),(8.01,0.3),(12.98,0.3),(12.98,1.085),(13.32,1.085),(13.32,0.3),(17.625,0.3),(17.625,0.68),(17.855,0.68),(17.855,0.3),(19.685,0.3),(19.685,0.995),(19.915,0.995),(19.915,0.3),(21.28,0.3),(21.28,-0.3)],
  [(19.735,2.46),(19.735,3.62),(17.59,3.62),(17.59,2.845),(17.25,2.845),(17.25,3.62),(13.27,3.62),(13.27,2.995),(12.93,2.995),(12.93,3.62),(7.91,3.62),(7.91,3.35),(7.57,3.35),(7.57,3.62),(5.59,3.62),(5.59,3.18),(5.25,3.18),(5.25,3.62),(1.6,3.62),(1.6,2.845),(1.26,2.845),(1.26,3.62),(0,3.62),(0,4.22),(21.28,4.22),(21.28,3.62),(19.965,3.62),(19.965,2.46)])
R(gf180mcu_fd_sc_mcu7t5v0_, dualgate, [(-0.28,-0.28,21.56,4.2)])
R(gf180mcu_fd_sc_mcu7t5v0_, v5_xtor, [(0,0,21.28,3.92)])
P(gf180mcu_fd_sc_mcu7t5v0_, lvpwell, [(-0.43,-0.43),(-0.43,1.76),(6.245,1.76),(6.245,1.885),(10,1.885),(10,1.76),(21.71,1.76),(21.71,-0.43)])
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('Q', (21,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('SE', (0.84,1.4), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('SI', (1.96,1.4), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VDD', (1.4,3.92), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VSS', (1.4,0), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('CLK', (5.88,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('D', (4.2,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Vendor GLOBALFOUNDRIES', (0,2), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Product GF018hv5v_mcu_sc7', (0,1.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Version 2015q2v1', (0,1), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Metric 1.00', (0,0.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VNW', (0.345,3.92), layer=21, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VPW', (0.34,-0.085), layer=204, texttype=10))

lib.write_gds('gf180mcu_fd_sc_mcu7t5v0__sdffq_1.gds')
