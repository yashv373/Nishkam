* Circuit, read from the shapes
.subckt gf180mcu_fd_sc_mcu7t5v0__or4_2 A1 A2 A3 A4 VDD VNW VSS Z
XM1 n1 A1 VSS VSUBS nfet_05v0 w=0.465u l=0.6u
XM2 VSS A2 n1 VSUBS nfet_05v0 w=0.465u l=0.6u
XM3 n1 A3 VSS VSUBS nfet_05v0 w=0.465u l=0.6u
XM4 VSS A4 n1 VSUBS nfet_05v0 w=0.465u l=0.6u
XM5 Z n1 VSS VSUBS nfet_05v0 w=0.82u l=0.6u m=2
XM6 n2 A1 n1 VNW pfet_05v0 w=1.22u l=0.5u
XM7 n3 A2 n2 VNW pfet_05v0 w=1.22u l=0.5u
XM8 n4 A3 n3 VNW pfet_05v0 w=1.22u l=0.5u
XM9 VDD A4 n4 VNW pfet_05v0 w=1.22u l=0.5u
XM10 Z n1 VDD VNW pfet_05v0 w=1.22u l=0.5u m=2
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
def P(c, l, *ps):  # polygons
    for p in ps: c.add(gdstk.Polygon(p, *l))
boundary = (0, 0)
nwell = (21, 0)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
dualgate = (55, 0)
v5_xtor = (112, 1)
lvpwell = (204, 0)

gf180mcu_fd_sc_mcu7t5v0_ = lib.new_cell('gf180mcu_fd_sc_mcu7t5v0__or4_2')
R(gf180mcu_fd_sc_mcu7t5v0_, boundary, [(0,0,7.84,3.92)])
R(gf180mcu_fd_sc_mcu7t5v0_, nwell, [(-0.43,1.76,8.27,4.35)])
R(gf180mcu_fd_sc_mcu7t5v0_, comp, [(0.28,2.36,7.34,3.58)])
P(gf180mcu_fd_sc_mcu7t5v0_, comp, [(4.88,0.34),(4.88,0.36),(0.18,0.36),(0.18,0.825),(4.88,0.825),(4.88,1.16),(7.44,1.16),(7.44,0.34)])
P(gf180mcu_fd_sc_mcu7t5v0_, poly2, [(0.62,0.14),(0.62,2.04),(0.72,2.04),(0.72,3.8),(1.22,3.8),(1.22,0.14)],
  [(1.74,0.14),(1.74,2.04),(1.84,2.04),(1.84,3.8),(2.34,3.8),(2.34,0.14)],
  [(2.86,0.14),(2.86,2.04),(2.96,2.04),(2.96,3.8),(3.46,3.8),(3.46,0.14)],
  [(3.98,0.14),(3.98,2.04),(4.08,2.04),(4.08,3.8),(4.58,3.8),(4.58,0.14)],
  [(5.28,0.12),(5.28,1.385),(5.33,1.385),(5.33,3.8),(5.83,3.8),(5.83,1.97),(6.4,1.97),(6.4,3.8),(6.9,3.8),(6.9,1.385),(7,1.385),(7,0.12),(6.4,0.12),(6.4,1.74),(5.88,1.74),(5.88,0.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, pplus, [(-0.2,1.76,8.04,4.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, nplus, [(-0.2,-0.2,8.04,1.76)])
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 0.25, 0.43, 0.22, 0.22, 3, 1, 2.24, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 0.74, 1.72, 0.22, 0.22, 4, 1, 1.12, 0)
R(gf180mcu_fd_sc_mcu7t5v0_, contact, [(1.37,0.535,1.59,0.755), (3.61,0.535,3.83,0.755), (7.15,0.56,7.37,0.78), (6.03,0.735,6.25,0.955), (5.475,1.85,5.695,2.07), (6.47,1.85,6.69,2.07), (0.35,2.63,0.57,2.85), (4.825,2.63,5.045,2.85), (5.98,2.63,6.2,2.85), (7.05,3.095,7.27,3.315), (0.35,3.1,0.57,3.32), (4.825,3.1,5.045,3.32), (5.98,3.1,6.2,3.32)])
A(gf180mcu_fd_sc_mcu7t5v0_, metal1, 1.78, 1.48, 0.36, 1.91, 3, 1, 1.12, 0)
R(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(0.66,1.015,1.02,2.29)])
P(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(1.31,0.53),(1.31,2.53),(0.345,2.53),(0.345,3.39),(0.575,3.39),(0.575,2.76),(1.54,2.76),(1.54,1.18),(5.03,1.18),(5.03,2.075),(6.75,2.075),(6.75,1.845),(5.26,1.845),(5.26,0.945),(3.89,0.945),(3.89,0.53),(3.55,0.53),(3.55,0.945),(1.65,0.945),(1.65,0.53)],
  [(6.025,0.53),(6.025,1.56),(7.01,1.56),(7.01,2.36),(5.97,2.36),(5.97,3.39),(6.585,3.39),(6.585,2.68),(7.28,2.68),(7.28,1.24),(6.585,1.24),(6.585,0.53)],
  [(0,-0.3),(0,0.3),(0.19,0.3),(0.19,0.655),(0.53,0.655),(0.53,0.3),(2.43,0.3),(2.43,0.655),(2.77,0.655),(2.77,0.3),(4.67,0.3),(4.67,0.655),(5.01,0.655),(5.01,0.3),(7.145,0.3),(7.145,0.9),(7.375,0.9),(7.375,0.3),(7.84,0.3),(7.84,-0.3)],
  [(4.82,2.53),(4.82,3.62),(0,3.62),(0,4.22),(7.84,4.22),(7.84,3.62),(7.275,3.62),(7.275,2.99),(7.045,2.99),(7.045,3.62),(5.05,3.62),(5.05,2.53)])
R(gf180mcu_fd_sc_mcu7t5v0_, dualgate, [(-0.28,-0.28,8.12,4.2)])
R(gf180mcu_fd_sc_mcu7t5v0_, v5_xtor, [(0,0,7.84,3.92)])
R(gf180mcu_fd_sc_mcu7t5v0_, lvpwell, [(-0.43,-0.43,8.27,1.76)])
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A1', (0.84,1.4), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A3', (3.08,2.52), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A4', (4.2,2.52), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VDD', (3.92,3.935), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VSS', (3.92,-0.01), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('Z', (6.44,1.4), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A2', (1.96,2.52), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Vendor GLOBALFOUNDRIES', (0,2), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Product GF018hv5v_mcu_sc7', (0,1.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Version 2015q2v1', (0,1), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Metric 1.00', (0,0.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VNW', (0.345,3.92), layer=21, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VPW', (0.34,-0.085), layer=204, texttype=10))

lib.write_gds('gf180mcu_fd_sc_mcu7t5v0__or4_2.gds')
